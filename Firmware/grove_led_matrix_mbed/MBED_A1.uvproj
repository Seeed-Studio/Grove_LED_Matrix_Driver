# Keil uVision project MBED_A1.uvproj, settings and files
target mbed NUCLEO_F103RB (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MBED_A1 +hex
  AfterMake: fromelf --bin -o build\MBED_A1_NUCLEO_F103RB.bin build\MBED_A1.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_NUCLEO_F103RB,  TARGET_FF_MORPHO,  TARGET_CORTEX_M,  TOOLCHAIN_ARM_MICRO,  TARGET_STM32F1,  __MBED__=1,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1447985702.8,  TARGET_STM,  __CORTEX_M3,  TARGET_M3,  TOOLCHAIN_ARM,  TARGET_STM32F103RB,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  env;  mbed;  mbed\api;  mbed\common;  mbed\hal;  mbed\targets;  mbed\targets\cmsis;  mbed\targets\cmsis\TARGET_STM;  mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1;  mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB;  mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\TOOLCHAIN_ARM_MICRO;  mbed\targets\hal;  mbed\targets\hal\TARGET_STM;  mbed\targets\hal\TARGET_STM\TARGET_STM32F1;  mbed\targets\hal\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\TOOLCHAIN_ARM_MICRO\stm32f103xb.sct
  group src
    ./: main.cpp
    ./: matrix.cpp font.c
  group hal
    mbed/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/: startup_stm32f103xb.S sys.cpp
    mbed/targets/cmsis/TARGET_STM/TARGET_STM32F1/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
    mbed/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: cmsis_nvic.c hal_tick.c system_stm32f1xx.c
    mbed/targets/hal/TARGET_STM/TARGET_STM32F1/: analogin_api.c gpio_api.c gpio_irq_api.c i2c_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed/targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: PeripheralPins.c
  group mbed
    mbed/common/: assert.c board.c error.c gpio.c lp_ticker_api.c mbed_interface.c pinmap_common.c rtc_time.c semihost_api.c ticker_api.c us_ticker_api.c wait_api.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
